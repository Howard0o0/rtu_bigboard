# IAR project Backup of RTUtest_GP.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 5500
  General.GHeapSize2: 6000
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5438a.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430 Generic MSP430 device
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: adc.c adc.h BC95.c BC95.h blueTooth.c blueTooth.h camera.c camera.h common.c common.h Console.c Console.h debug.c debug.h flash.c flash.h flow.c flow.h GSM.c GSM.h GTM900C.c GTM900C.h hydrologycommand.c hydrologycommand.h hydrologytask.c hydrologytask.h ioDev.c ioDev.h led.c led.h main.c main.h message.c message.h msp430common.h packet.c packet.h reportbinding .c reportbinding.h rom.c rom.h rtc.c rtc.h Sampler.c Sampler.h store.c store.h timer.c timer.h uart0.c uart0.h uart1.c uart1.h uart2.c uart2.h uart3.c uart3.h uart_config.c uart_config.h wifi_config.c wifi_config.h
