<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\RTUV3_0908.ewp</path>
    </project>
    <batchBuild />
</workspace>
