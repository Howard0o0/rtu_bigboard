# IAR project RTUtest_GP.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 5048
  General.GHeapSize2: 6000
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: Driverlib
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5438a.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430 Generic MSP430 device
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: adc.c adc.h BC95.c BC95.h blueTooth.c blueTooth.h camera.c camera.h common.c common.h Console.c Console.h debug.c debug.h dtu.c dtu.h flash.c flash.h flow.c flow.h GSM.c GSM.h GTM900C.c GTM900C.h hydrologycommand.c hydrologycommand.h hydrologytask.c hydrologytask.h ioDev.c ioDev.h led.c led.h lowpower.c lowpower.h main.c main.h message.c message.h msp430common.h packet.c packet.h reportbinding .c reportbinding.h rom.c rom.h rtc.c rtc.h Sampler.c Sampler.h store.c store.h sys_status.c sys_status.h timer.c timer.h uart0.c uart0.h uart1.c uart1.h uart2.c uart2.h uart3.c uart3.h uart_config.c uart_config.h wifi_config.c wifi_config.h
  group Driverlib
    Driverlib/: adc10_a.c adc10_a.h adc12_a.c adc12_a.h aes.c aes.h battbak.c battbak.h comp_b.c comp_b.h crc.c crc.h ctsd16.c ctsd16.h dac12_a.c dac12_a.h dma.c dma.h driverlib.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h flashctl.c flashctl.h gpio.c gpio.h lcd_b.c lcd_b.h lcd_c.c lcd_c.h ldopwr.c ldopwr.h mpy32.c mpy32.h oa.c oa.h pmap.c pmap.h pmm.c pmm.h ram.c ram.h ref.c ref.h rtc_a.c rtc_a.h rtc_b.c rtc_b.h rtc_c.c rtc_c.h sd24_b.c sd24_b.h sfr.c sfr.h sysctl.c sysctl.h tec.c tec.h timer_a.c timer_a.h timer_b.c timer_b.h timer_d.c timer_d.h tlv.c tlv.h ucs.c ucs.h usci_a_spi.c usci_a_spi.h usci_a_uart.c usci_a_uart.h usci_b_i2c.c usci_b_i2c.h usci_b_spi.c usci_b_spi.h wdt_a.c wdt_a.h
